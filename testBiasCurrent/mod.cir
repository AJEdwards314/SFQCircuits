* Synaptic Test Circuit

B01        2          3          jmitll
B02        0          2          jmitll
IB0        0          1          pwl(0 0 5p {}u)
L01        2          4          2p
L02        1          2          2p
R0L        4          0          2
VIN        3          0          pwl(0 0 7.0P 280.0U 14.0P 0 21.0P 280.0U 28.0P 0 35.0P 280.0U 42.0P 0 49.0P 280.0U 56.0P 0 63.0P 280.0U 70.0P 0 77.0P 280.0U 84.0P 0 91.0P 280.0U 98.0P 0 105.0P 280.0U 112.0P 0 119.0P 280.0U 126.0P 0 133.0P 280.0U 140.0P 0 147.0P 280.0U 154.0P 0 161.0P 280.0U 168.0P 0 175.0P 280.0U 182.0P 0 189.0P 280.0U 196.0P 0 203.0P 280.0U 210.0P 0 217.0P 280.0U 224.0P 0 231.0P 280.0U 238.0P 0 245.0P 280.0U 252.0P 0 259.0P 280.0U 266.0P 0 273.0P 280.0U 280.0P 0 287.0P 280.0U 294.0P 0 301.0P 280.0U 308.0P 0 315.0P 280.0U 322.0P 0 329.0P 280.0U 336.0P 0 343.0P 280.0U 350.0P 0 357.0P 280.0U 364.0P 0 371.0P 280.0U 378.0P 0 385.0P 280.0U 392.0P 0 399.0P 280.0U 406.0P 0 413.0P 280.0U 420.0P 0 427.0P 280.0U 434.0P 0 441.0P 280.0U 448.0P 0 455.0P 280.0U 462.0P 0 469.0P 280.0U 476.0P 0 483.0P 280.0U 490.0P 0 497.0P 280.0U 504.0P 0 511.0P 280.0U 518.0P 0 525.0P 280.0U 532.0P 0 539.0P 280.0U 546.0P 0 553.0P 280.0U 560.0P 0 567.0P 280.0U 574.0P 0 581.0P 280.0U 588.0P 0 595.0P 280.0U 602.0P 0 609.0P 280.0U 616.0P 0 623.0P 280.0U 630.0P 0 637.0P 280.0U 644.0P 0 651.0P 280.0U 658.0P 0 665.0P 280.0U 672.0P 0 679.0P 280.0U 686.0P 0 693.0P 280.0U 700.0P 0 707.0P 280.0U 714.0P 0 721.0P 280.0U 728.0P 0 735.0P 280.0U 742.0P 0 749.0P 280.0U 756.0P 0 763.0P 280.0U 770.0P 0 777.0P 280.0U 784.0P 0 791.0P 280.0U 798.0P 0 805.0P 280.0U 812.0P 0 819.0P 280.0U 826.0P 0 833.0P 280.0U 840.0P 0 847.0P 280.0U 854.0P 0 861.0P 280.0U 868.0P 0 875.0P 280.0U 882.0P 0 889.0P 280.0U 896.0P 0 903.0P 280.0U 910.0P 0 917.0P 280.0U 924.0P 0 931.0P 280.0U 938.0P 0 945.0P 280.0U 952.0P 0 959.0P 280.0U 966.0P 0 973.0P 280.0U 980.0P 0 987.0P 280.0U)

.temp 4.2
.model jmitll jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rN=16, icrit=0.15mA)
.tran 0.1p 1000p 0 0.1p
.print PHASE B02
.end
